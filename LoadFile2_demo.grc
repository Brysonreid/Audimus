options:
  parameters:
    author: Bryson
    generate_options: no_gui
    id: LoadFile2_demo
    output_language: python
    run_options: run
    title: LoadAudioFile
  states: {}

blocks:
- name: Audio_Decimation
  id: variable_config
  parameters:
    config_file: LimeSDRConf.ini
    option: Audio_Decimation
    section: Demodulation
    type: int
    value: '5'
    writeback: None
  states: {}
- name: Demod_Decimation
  id: variable_config
  parameters:
    config_file: LimeSDRConf.ini
    option: Decimation
    section: Demodulation
    type: int
    value: '16'
    writeback: None
  states: {}
- name: Demod_Quadrature
  id: variable_config
  parameters:
    config_file: LimeSDRConf.ini
    option: Quadrature
    section: Demodulation
    type: real
    value: '240000'
    writeback: None
  states: {}
- name: Storage_File
  id: variable_config
  parameters:
    config_file: LimeSDRConf.ini
    option: File
    section: Storage
    type: string
    value: Recordings\SDRdata
    writeback: None
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: Audio_Decimation
    quad_rate: Demod_Quadrature
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: C:\Users\Bryso\OneDrive\Documents\GitHub\Audimus\Pi\Recordings\SDRdata2025-04-02-15_06_03_compress
    repeat: 'False'
    type: short
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: '1.0'
    vector_input: 'False'
  states: {}

connections:
- [analog_wfm_rcv_0, '0', audio_sink_0, '0']
- [blocks_file_source_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', analog_wfm_rcv_0, '0']

metadata:
  file_format: 1
