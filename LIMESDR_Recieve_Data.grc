options:
  parameters:
    author: Bryson
    generate_options: no_gui
    id: LIMESDR_Recieve_Data
    output_language: python
    run_options: run
    title: LIMESDR_Recieve_Data
  states: {}

blocks:
- name: Center_Frequency
  id: variable_config
  parameters:
    config_file: LimeSDRConf.ini
    option: Frequency
    section: Radio
    type: real
    value: '138000000'
    writeback: None
  states: {}
- name: File_Size
  id: variable_config
  parameters:
    config_file: LimeSDRConf.ini
    option: FileSize
    section: Storage
    type: int
    value: '57600000'
    writeback: None
  states: {}
- name: Filter_Decimation
  id: variable_config
  parameters:
    config_file: LimeSDRConf.ini
    option: Decimation
    section: Filter
    type: int
    value: '1'
    writeback: None
  states: {}
- name: Storage_File
  id: variable_config
  parameters:
    config_file: LimeSDRConf.ini
    option: File
    section: Storage
    type: string
    value: Recordings\SDRdata
    writeback: None
  states: {}
- name: samp_rate
  id: variable_config
  parameters:
    config_file: LimeSDRConf.ini
    option: Sample_Rate
    section: Radio
    type: real
    value: '2400000'
    writeback: None
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '5e-3'
    reference: '1.0'
    type: complex
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: Storage_File
    type: complex
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: File_Size
    type: complex
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: samp_rate/4
    decim: Filter_Decimation
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: samp_rate/8
    win: window.WIN_HAMMING
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '10'
    fbw: '0.2'
    interp: '1'
    type: ccc
  states: {}
- name: soapy_limesdr_source_0_0
  id: soapy_limesdr_source
  parameters:
    bandwidth: '40000000'
    center_freq: Center_Frequency
    dev_args: '""'
    gain: '80'
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [analog_agc_xx_0, '0', blocks_head_0, '0']
- [blocks_head_0, '0', blocks_file_sink_0_0, '0']
- [low_pass_filter_0_0, '0', rational_resampler_xxx_0_0, '0']
- [rational_resampler_xxx_0_0, '0', analog_agc_xx_0, '0']
- [soapy_limesdr_source_0_0, '0', low_pass_filter_0_0, '0']

metadata:
  file_format: 1
