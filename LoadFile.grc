options:
  parameters:
    author: Bryson
    generate_options: no_gui
    id: LoadFile
    output_language: python
    run_options: run
    title: LoadAudioFile
  states: {}

blocks:
- name: Storage_File
  id: variable_config
  parameters:
    config_file: LimeSDRConf.ini
    option: File
    section: Storage
    type: string
    value: Recordings\SDRdata
    writeback: None
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: Storage_File
    repeat: 'False'
    type: float
  states: {}

connections:
- [blocks_file_source_0, '0', audio_sink_0, '0']

metadata:
  file_format: 1
