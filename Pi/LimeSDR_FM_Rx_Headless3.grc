options:
  parameters:
    author: Bryson
    generate_options: no_gui
    id: LimeSDR_FM_Rx_Headless
    output_language: python
    run_options: run
    title: LimeSDR_FM_Rx_Headless
  states: {}

blocks:
- name: Audio_Decimation
  id: variable_config
  parameters:
    config_file: LimeSDRConf.ini
    option: Audio_Decimation
    section: Demodulation
    type: int
    value: '5'
    writeback: None
  states: {}
- name: Center_Frequency
  id: variable_config
  parameters:
    config_file: LimeSDRConf.ini
    option: Frequency
    section: Radio
    type: real
    value: '138000000'
    writeback: None
  states: {}
- name: Demod_Decimation
  id: variable_config
  parameters:
    config_file: LimeSDRConf.ini
    option: Decimation
    section: Demodulation
    type: int
    value: '16'
    writeback: None
  states: {}
- name: Demod_Quadrature
  id: variable_config
  parameters:
    config_file: LimeSDRConf.ini
    option: Quadrature
    section: Demodulation
    type: real
    value: '240000'
    writeback: None
  states: {}
- name: Filter_Cut_Off_Frequency
  id: variable_config
  parameters:
    config_file: LimeSDRConf.ini
    option: Cut_Off_Frequency
    section: Filter
    type: real
    value: '75000'
    writeback: None
  states: {}
- name: Filter_Decimation
  id: variable_config
  parameters:
    config_file: LimeSDRConf.ini
    option: Decimation
    section: Filter
    type: int
    value: '1'
    writeback: None
  states: {}
- name: Filter_Transmission_Width
  id: variable_config
  parameters:
    config_file: LimeSDRConf.ini
    option: Transmission_Width
    section: Filter
    type: real
    value: '25000'
    writeback: None
  states: {}
- name: Interpolation
  id: variable_config
  parameters:
    config_file: LimeSDRConf.ini
    option: Interpolation
    section: Demodulation
    type: int
    value: '5'
    writeback: None
  states: {}
- name: Storage_File
  id: variable_config
  parameters:
    config_file: LimeSDRConf.ini
    option: File
    section: Storage
    type: string
    value: C:\Users\bryso\Downloads\SDRdata
    writeback: None
  states: {}
- name: samp_rate
  id: variable_config
  parameters:
    config_file: LimeSDRConf.ini
    option: Sample_Rate
    section: Radio
    type: real
    value: '768000'
    writeback: None
  states: {}
- name: analog_fm_deemph_0
  id: analog_fm_deemph
  parameters:
    samp_rate: '48000'
    tau: '75e-6'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: Audio_Decimation
    quad_rate: Demod_Quadrature
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '240000'
    low_cutoff_freq: '15000'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '1000000'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: SDRdata
    type: float
  states: {}
- name: blocks_head_0_0
  id: blocks_head
  parameters:
    num_items: '2880000'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: Demod_Decimation
    interp: Interpolation
    type: ccc
  states: {}
- name: soapy_limesdr_source_0
  id: soapy_limesdr_source
  parameters:
    bandwidth: '40000000'
    center_freq: Center_Frequency
    dev_args: '""'
    gain: '80'
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [analog_fm_deemph_0, '0', blocks_head_0_0, '0']
- [analog_wfm_rcv_0, '0', analog_fm_deemph_0, '0']
- [band_pass_filter_0, '0', rational_resampler_xxx_0, '0']
- [blocks_head_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_file_sink_0, '0']
- [rational_resampler_xxx_0, '0', analog_wfm_rcv_0, '0']
- [soapy_limesdr_source_0, '0', band_pass_filter_0, '0']

metadata:
  file_format: 1
